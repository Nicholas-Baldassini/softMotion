Commit message: Fixed robot, used robot config from somoGym

File: URDFS/cylinder.urdf (robot description, URDF)
Before this commit: robot cylinder, 1 links, 0 joints
Links:
- link cylinder: mass 0.3 -> 100.3; geometry collision cylinder length=1.5 radius=1.0; visual cylinder length=1.5 radius=1.0
